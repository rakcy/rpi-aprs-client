<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>aprs_receive</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Attack</value></param>
<param><key>value</key><value>0.8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Decay</value></param>
<param><key>value</key><value>0.1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_samp</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_frequency</value></param>
<param><key>value</key><value>145e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cutoff_frequency</value></param>
<param><key>value</key><value>100e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>audio_samp*20</value></param>
</block>
<block>
<key>afsk_ax25decode</key>
<param><key>id</key><value>afsk_ax25decode_1_0</value></param>
<param><key>debug_level</key><value>1</value></param>
<param><key>sample_rate</key><value>audio_samp</value></param>
</block>
<block>
<key>analog_nbfm_rx</key>
<param><key>id</key><value>analog_nbfm_rx_0</value></param>
<param><key>audio_rate</key><value>audio_samp</value></param>
<param><key>max_dev</key><value>5e3</value></param>
<param><key>quad_rate</key><value>int(samp_rate)</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0_0_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>high_cutoff_freq</key><value>2450</value></param>
<param><key>low_cutoff_freq</key><value>950</value></param>
<param><key>samp_rate</key><value>audio_samp</value></param>
<param><key>width</key><value>100</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>append</key><value>True</value></param>
<param><key>file</key><value>aprs_web_client/received_packets.log</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>blocks_sub_xx_0_0_0_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>detectMarkSpace</key>
<param><key>id</key><value>detectMarkSpace_0_0_0</value></param>
<param><key>attack</key><value>Attack</value></param>
<param><key>decay</key><value>Decay</value></param>
<param><key>Frequency</key><value>1200</value></param>
<param><key>samp_rate</key><value>audio_samp</value></param>
</block>
<block>
<key>detectMarkSpace</key>
<param><key>id</key><value>detectMarkSpace_1_0_0</value></param>
<param><key>attack</key><value>Attack</value></param>
<param><key>decay</key><value>Decay</value></param>
<param><key>Frequency</key><value>2200</value></param>
<param><key>samp_rate</key><value>audio_samp</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>bb_gain0</key><value>0</value></param>
<param><key>bw0</key><value>2e6</value></param>
<param><key>dc_offset_mode0</key><value>2</value></param>
<param><key>freq0</key><value>center_frequency</value></param>
<param><key>gain_mode0</key><value>True</value></param>
<param><key>if_gain0</key><value>0</value></param>
<param><key>iq_balance_mode0</key><value>2</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>afsk_ax25decode_1_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_nbfm_rx_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0_0_0</source_block_id><sink_block_id>detectMarkSpace_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0_0_0</source_block_id><sink_block_id>detectMarkSpace_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0_0_0_0</source_block_id><sink_block_id>afsk_ax25decode_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>detectMarkSpace_0_0_0</source_block_id><sink_block_id>blocks_sub_xx_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>detectMarkSpace_1_0_0</source_block_id><sink_block_id>blocks_sub_xx_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>band_pass_filter_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>analog_nbfm_rx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
